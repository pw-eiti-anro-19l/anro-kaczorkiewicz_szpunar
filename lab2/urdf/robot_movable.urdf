Commit message: lab3 zrobione

File: lab2/urdf/robot_movable.urdf (robot description, URDF)
Before this commit: robot forstRobot, 5 links, 4 joints
Links:
- link base_link: geometry visual cylinder length=0.1 radius=0.1
- link hand: geometry visual box size=${l_width} ${l_width} ${l_width}
